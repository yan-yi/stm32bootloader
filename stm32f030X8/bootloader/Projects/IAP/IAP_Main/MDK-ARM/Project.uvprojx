# Keil uVision project Project.uvprojx, settings and files
target STM32091C_EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32030C8 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32091C_EVAL;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/CPU;..\..\..\..\Drivers\BSP\Components\spi1;..\..\..\..\Drivers\BSP\Components\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Example/User
    ../Src/: flash_if.c stm32f0xx_it.c ymodem.c common.c menu.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
    ../../../../Drivers/BSP/Components/usart/: usart.c
    ../../../../Drivers/BSP/Components/spiflash/: spi_flash.c
    ../../../../Drivers/BSP/Components/spi1/: spi1.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c
software components: CMSIS:CORE 5.0.1
