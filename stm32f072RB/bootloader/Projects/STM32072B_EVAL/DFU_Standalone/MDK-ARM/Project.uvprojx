# Keil uVision project Project.uvprojx, settings and files
target STM32072B_EVAL_USB (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32072B_EVAL_USB +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_STM32072B_EVAL,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32072B_EVAL;../../../../Drivers/BSP/Components/Common;../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers\BSP\Components\spiflash
    ../../../../Drivers/BSP/Components/spiflash/: spi_flash.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Middlewares/STM32_USBD_Library/Class/DFU
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_cortex.c
  group Application/User
    ../Src/: usbd_dfu_flash.c stm32f0xx_it.c main.c usbd_conf.c usbd_desc.c usbd_dfu_spiflash.c uart.c timebase.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers\BSP\Components\spi
    ../../../../Drivers/BSP/Components/spi/: spi.c
software components: CMSIS:CORE 5.1.2
